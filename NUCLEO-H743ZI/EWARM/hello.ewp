# IAR project hello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1310F128 TexasInstruments CC1310F128
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: -f; configPkg/compiler.opt.defs; -I$PROJ_DIR$; -DDeviceFamily_CC13X0; -I$SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source; -I$SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/posix/iar; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: hello.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_CC1310_LAUNCHXL_TIRTOS.icf
  ILINK.IlinkExtraOptions: -f; configPkg/linker.cmd; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m3/grlib.a; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m3/spiffs_cc26xx.a; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/dpl/lib/dpl_cc13x0.arm3; $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/devices/cc13x0/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M3
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group (top)
    ./: hello.cfg
  group Hello Example/Documentation
    $SIMPLELINK_CC13X0_SDK_INSTALL_DIR$/source/ti/boards/CC1310_LAUNCHXL/: Board.html
    ./: README.html README.md
  group Hello Example/Header files
    ./: Board.h CC1310_LAUNCHXL.h
  group Hello Example/Source files
    ./: CC1310_LAUNCHXL.c CC1310_LAUNCHXL_fxns.c ccfg.c hello.c hello_CC1310_LAUNCHXL_TIRTOS.icf

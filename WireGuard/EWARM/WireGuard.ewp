# IAR project WireGuard.ewp, settings and files
configuration WireGuard (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx; SUPPORT_DRAM; SWG_DEVICE
  ICCARM.CCIncludePath2: ../../Common/lib; ../../Common/app; ../../Common/app/rf; ../../Common/app/swg; ../../Common/app/shell; ../../Common/Lib/st; ../task; ../FATFS/Target; ../FATFS/App; ../Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: WireGuard.hex
  ILINK.IlinkOutputFile: WireGuard.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h743xx.s
  group Application/User/App
    ../../Common/App/: comport.c comport.h config.h task_main.c task_main.h
    ../../Common/App/swg/: config.c target.h
  group Application/User/App/rf
    ../../Common/App/rf/: rf.c rf.h
  group Application/User/App/shell
    ../../Common/App/shell/: shell.c shell.h shell_1231.c shell_adc.c shell_cmd.c shell_config.c shell_monitor.c shell_rf.c shell_scan.c shell_sdram.c
  group Application/User/Core
    ../Core/Src/: freertos.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_TIM.c stm32h7xx_it.c
  group Application/User/FatFs/App
    ../FATFS/App/: fatfs.c
  group Application/User/FatFs/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: fatfs_platform.c
  group Application/User/Lib
    ../../Common/Lib/: adc.c adc.h assert.h crc16.c crc16.h monitor.c monitor.h ret_value.h scan.c scan.h sdram.c sdram.h serial.c serial.h system.c system.h time2.c time2.h trace.c trace.h utils.c utils.h
  group Application/User/Lib/st
    ../../Common/Lib/st/: sx1231.c
  group Application/User/Lib/sys
    ../../Common/Lib/sys/: stm32h7xx_sys.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
